## modules/debounce/Kconfig
```kconfig
config DROID2_DEBOUNCE
        tristate "Droid2 keyboard debounce fix"
        default m
```
